<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Tx_Module_Manager.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Tx_Module.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BatchBuild</name>
            <member>
                <project>Tx_Module</project>
                <configuration>Tx_Module</configuration>
            </member>
            <member>
                <project>Tx_Module_Manager</project>
                <configuration>Tx_Module_Manager</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
